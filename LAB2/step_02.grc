options:
  parameters:
    generate_options: qt_gui
    id: step_02
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: my_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    comment: 'debrayage : à expliquer'
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bida/Downloads/LAB2-20260323/sine_16.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: my_const
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_pack', 
                  in_sig=[(np.uint8, 2)], # Entrée : vecteur de 2 octets (bytes)
                  out_sig=[np.int16]      # Sortie : 1 mot de 16 bits (short)
              )

          def work(self, input_items, output_items):
              input_chars = input_items[0]
              output = output_items[0]
              
              # On convertit d'abord en int16 pour éviter les débordements (overflow) lors du décalage
              low_byte = input_chars[:, 0].astype(np.int16)  # LSB en premier d'après le TP
              high_byte = input_chars[:, 1].astype(np.int16) # MSB en second
              
              # Recomposition du mot de 16 bits
              output[:] = (high_byte << 8) | low_byte
              
              return len(output)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_unpack',
                  in_sig=[np.int16],       # Entrée : 1 mot de 16 bits (short)
                  out_sig=[(np.uint8, 2)]  # Sortie : vecteur de 2 octets (bytes)
              )

          def work(self, input_items, output_items):
              in_data = input_items[0]
              out_data = output_items[0]
              
              # Masque bit-à-bit pour récupérer le LSB (Octet de poids faible) en premier
              out_data[:, 0] = (in_data & 0xFF).astype(np.uint8) 
              
              # Décalage de 8 bits vers la droite puis masque pour le MSB (Octet de poids fort)
              out_data[:, 1] = ((in_data >> 8) & 0xFF).astype(np.uint8)
              
              return len(out_data)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '150000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_short_1, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_throttle2_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle2_1, '0', blocks_short_to_float_0, '0']
- [blocks_throttle2_1, '0', epy_block_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_short_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_short_to_float_0_0, '0']
- [epy_block_1, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
