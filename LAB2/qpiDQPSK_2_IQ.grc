options:
  parameters:
    generate_options: hb
    id: qpiDQPSK_2_IQ
    output_language: python
    title: pi/4-DQPSK to IQ
  states: {}

blocks:
- name: my_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: QpiDQPSKdemo_0
  id: QpiDQPSKdemo
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: short
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_short_to_float_0_0_0_1
  id: blocks_short_to_float
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_short_to_float_0_0_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_pack',
                  in_sig=[(np.uint8,2)],
                  out_sig=[np.int16]
              )

          def work(self, input_items, output_items):
              input_chars = input_items[0]
              output = output_items[0]
              for i in range(len(output)):
                  high_byte = input_chars[i][0]
                  low_byte  = input_chars[i][1]
                  output[i] = (high_byte << 8) | low_byte
              return len(output)
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '2048000'
  states: {}

connections:
- [QpiDQPSKdemo_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_deinterleave_0, '0', blocks_short_to_float_0_0_0_1, '0']
- [blocks_deinterleave_0, '1', blocks_short_to_float_0_0_0_1_0, '0']
- [blocks_magphase_to_complex_0, '0', pad_sink_3, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0_0_0_1, '0', blocks_magphase_to_complex_0, '0']
- [blocks_short_to_float_0_0_0_1_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [epy_block_1, '0', blocks_deinterleave_0, '0']
- [pad_source_0, '0', QpiDQPSKdemo_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
