options:
  parameters:
    generate_options: hb
    id: IQ_2_qpiDQPSK
    output_language: python
    title: IQ to pi/4 DQPSK
  states: {}

blocks:
- name: my_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: QpiDQPSKmod_0
  id: QpiDQPSKmod
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: byte
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: my_const
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_unpack',  
                  in_sig=[np.int16],
                  out_sig=[(np.uint8,2)]
              )

          def work(self, input_items, output_items):
              input_shorts = input_items[0]
              output = output_items[0]        
              for i in range(len(input_shorts)):
                  val = input_shorts[i]
                  output[i][0] = (val >> 8) & 0xFF   # octet de PpF
                  output[i][1] = val & 0xFF          # octet de PmF
              return len(input_shorts)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '2048000'
  states: {}

connections:
- [QpiDQPSKmod_0, '0', pad_sink_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', QpiDQPSKmod_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', blocks_complex_to_magphase_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
