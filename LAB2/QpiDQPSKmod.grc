options:
  parameters:
    generate_options: hb
    id: QpiDQPSKmod
    output_language: python
    title: pi/4-DQPSK mod
  states: {}

blocks:
- name: my_const_1
  id: variable_constellation
  parameters:
    const_points: '[1, (1+1j)/math.sqrt(2)]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: subCarr_K
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: (1+1j)/math.sqrt(2)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, subCarr_K)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: subCarr_K+1
    type: complex
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,)*(subCarr_K//2)+(0,)
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: subCarr_K+1
    type: complex
  states: {}
- name: digital_constellation_encoder_bc_0_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: my_const_1
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import cmath
      import math


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,vsize=5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DQPSK_mod',   # will show up in GRC
                  in_sig=[(np.complex64,vsize)],
                  out_sig=[(np.complex64,vsize)]
              )
              self.vsize = vsize

          def work(self, input_items, output_items):
              # Récupération des vecteurs en entrée et en sortie
              in_vector = input_items[0]
              out_vector = output_items[0]
              
              # Application du filtre IIR sur chaque ligne du vecteur
              for i in range(in_vector.shape[0]):
      #            out_vector[i][0] = cmath.exp(1j * math.pi / 4)
                  out_vector[i][0] = in_vector[i][0]
                  for j in range(self.vsize-1):                
                      out_vector[i][j+1] = in_vector[i][j+1] * in_vector[i][j]
                  #out_vector[i] = np.pi/4.0-out_vector[i][::-1]
                  #out_vector[i]= in_vector[i]
              
              # Retourne le nombre d'éléments traités
              return len(out_vector)
    vsize: subCarr_K+1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_1, '0', digital_constellation_encoder_bc_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_xx_0, '1']
- [digital_constellation_encoder_bc_0_0_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0_0, '0']
- [pad_source_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
