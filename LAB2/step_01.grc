options:
  parameters:
    generate_options: qt_gui
    id: qst1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    comment: 'debrayage : à expliquer'
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bida/Downloads/LAB2-20260323/sine_16.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '66036'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_throttle2_1, '0']
- [blocks_float_to_short_1, '0', blocks_throttle2_0, '0']
- [blocks_interleave_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_interleave_0, '1']
- [blocks_throttle2_1, '0', blocks_interleave_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_short_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
