options:
  parameters:
    author: MA
    generate_options: qt_gui
    id: OFDM_wav_TS_step_00
    output_language: python
    title: OFDM_wav_TS_step_00
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: sine_1.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: I Signal
    label2: Q Signal
    nconnections: '2'
    size: (65536+500)*(17-16)
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_float_to_short_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', blocks_short_to_float_0, '0']
- [blocks_throttle2_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_short_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
