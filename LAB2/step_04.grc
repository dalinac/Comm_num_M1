options:
  parameters:
    generate_options: qt_gui
    id: OFDM_wav_TS_step_03
    output_language: python
    title: OFDM_wav_TS_step_03
  states: {}

blocks:
- name: audio_Fs
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: my_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: QpiDQPSKdemo_0
  id: QpiDQPSKdemo
  parameters: {}
  states: {}
- name: QpiDQPSKmod_0
  id: QpiDQPSKmod
  parameters: {}
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_Fs
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_short_to_float_0_0_0_1
  id: blocks_short_to_float
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_short_to_float_0_0_0_1_0
  id: blocks_short_to_float
  parameters:
    scale: 65536/2
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: received.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: audio_Fs
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: shortVivaldi.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_const
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: my_const
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_unpack',  
                  in_sig=[np.int16],
                  out_sig=[(np.uint8,2)]
              )

          def work(self, input_items, output_items):
              input_shorts = input_items[0]
              output = output_items[0]        
              for i in range(len(input_shorts)):
                  val = input_shorts[i]
                  output[i][0] = (val >> 8) & 0xFF   # octet de PpF
                  output[i][1] = val & 0xFF          # octet de PmF
              return len(input_shorts)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='my_short_to_char_pack',
                  in_sig=[(np.uint8,2)],
                  out_sig=[np.int16]
              )

          def work(self, input_items, output_items):
              input_chars = input_items[0]
              output = output_items[0]
              for i in range(len(output)):
                  high_byte = input_chars[i][0]
                  low_byte  = input_chars[i][1]
                  output[i] = (high_byte << 8) | low_byte
              return len(output)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: '64'
    srate: samp_rate
    type: float
    update_time: '0.010'
    ymax: '35000'
    ymin: '-35000'
  states: {}

connections:
- [QpiDQPSKdemo_0, '0', digital_constellation_decoder_cb_0, '0']
- [QpiDQPSKmod_0, '0', QpiDQPSKdemo_0, '0']
- [QpiDQPSKmod_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_deinterleave_0, '0', blocks_short_to_float_0_0_0_1, '0']
- [blocks_deinterleave_0, '1', blocks_short_to_float_0_0_0_1_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0_0_0_1, '0', audio_sink_0, '0']
- [blocks_short_to_float_0_0_0_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_short_to_float_0_0_0_1_0, '0', audio_sink_0, '1']
- [blocks_short_to_float_0_0_0_1_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_short_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_short_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', QpiDQPSKmod_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_1, '0', blocks_deinterleave_0, '0']
- [epy_block_1, '0', blocks_short_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
